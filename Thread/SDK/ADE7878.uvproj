# Keil uVision project ADE7878.uvproj, settings and files
target Thread (ARM-ADS)
  device: (Generic) NUC400 Series Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: ADE7878 +hex
  c flags: Optim=1 OneElfS=1
  c define: RVDS_ARMCM4_NUC4xx
  c include: ..\ADE7878\inc;..\app\inc;..\CMIS\CMSIS\Include;..\lib\inc;..\CMIS\Include;..\DS12864;..\freemodbus-v1.6.0\port;..\freemodbus-v1.6.0\modbus\ascii;..\freemodbus-v1.6.0\modbus;..\freemodbus-v1.6.0\modbus\functions;..\freemodbus-v1.6.0\modbus\include;..\freemodbus-v1.6.0\modbus\rtu;..\freemodbus-v1.6.0\modbus\tcp;..\User;..\eefs\inc;..\eefs\drivers\standalone_driver;..\eefs\libraries\eepromfs;..\eefs\libraries\microeefs;..\eefs\libraries\page_window;..\eefs\tools\eefstool\inc;..\Thread\applications;..\Thread\drivers;..\Thread\libcpu\arm\cortex-m4;..\Thread\libcpu\arm\common;..\Thread\include;..\eefs\eeprom;..\Weight\inc;..\doorinout;..\pid;..\freemodbus-v1.6.0\modbus_app
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/src/: main.c Usart.c Config.c
    ../DS12864/: ds12864.c
    ../User/: systimer.c
  group chip_lib
    ../lib/src/: acmp.c adc.c can.c cap.c clk.c crypto.c ebi.c emac.c fmc.c gpio.c i2c.c i2s.c pdma.c ps2.c pwm.c retarget.c rtc.c sc.c scuart.c sd.c spi.c sys.c uart.c usbd.c wdt.c wwdt.c timer_nuc.c
  group cpu
    ../CMIS/Source/: system_NUC472_442.c
    ../CMIS/Source/ARM/: startup_NUC472_442.s
  group ade7878dev
    ../ADE7878/src/: ADE7878_SPI.c ADE7878.c ADE7878_Int.c AD7878_Measure.c
  group readme
    ./readme/: readme.txt
  group modbus/port
    ../freemodbus-v1.6.0/port/: port.c portevent.c portserial.c porttimer.c user_mb_app.c
  group modbus/modbus/rtu
    ../freemodbus-v1.6.0/modbus/rtu/: mbrtu.c mbcrc.c
  group modbus/modbus/ascii
    ../freemodbus-v1.6.0/modbus/ascii/: mbascii.c
  group modbus/modbus/functions
    ../freemodbus-v1.6.0/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c btfunc.c
  group modbus/modbus/include
    ../freemodbus-v1.6.0/modbus/include/: mb.h mb_m.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group modbus/modbus/tcp
    ../freemodbus-v1.6.0/modbus/tcp/: mbtcp.c
  group modbus
    ../freemodbus-v1.6.0/modbus/: mb.c
  group eefs/libraries
    ../eefs/libraries/eepromfs/: eefs_fileapi.c
    ../eefs/libraries/microeefs/: microeefs.c
  group eefs/drivers
    ../eefs/drivers/standalone_driver/: eefs_filesys.c
  group eefs/include
    ../eefs/inc/: common_types.h eefs_config.h eefs_fileapi.h eefs_version.h
    ../eefs/drivers/standalone_driver/: eefs_filesys.h eefs_macros.h
  group eefs/eepromapp
    ../eefs/eepromapp/: eepromapp.c
  group eefs/eepromdev
    ../eefs/eeprom/: eeprom.c eeprom_low.c
  group thread/src
    ../Thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group thread/divers
    ../Thread/drivers/: board.c
  group thread/appliction
    ../Thread/applications/: application.c startup.c
    ../Thread/include/: rtconfig.h
  group thread/libcpu
    ../Thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../Thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group weight
    ../Weight/src/: weight.c
    ../Weight/inc/: weight.h
    ../Weight/: weight日志.txt
  group doorinout
    ../doorinout/: doorinout.c doorinout日志 doorinout.h
  group pid
    ../pid/: pidctrl.c PID日志 pidctrl.h DS18B20SROM.c ds18b20sech.c
  group modbus_app
    ../freemodbus-v1.6.0/modbus_app/: modbus_app.c
  group PowerMeasurment
    ../ADE7878/src/: PowerMeasurment.c
